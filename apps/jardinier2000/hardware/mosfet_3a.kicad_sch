File: apps/jardinier2000/hardware/mosfet_3a.kicad_sch (KiCad schematic)
At the start: 4 parts, among them Q1 AO3400A

Commit message: Working on v0.3
Parts:
- renumbered D2 to D6
